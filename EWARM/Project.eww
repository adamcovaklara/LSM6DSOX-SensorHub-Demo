<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IKS0LAB_SensorHub.ewp</path>
  </project>
  <batchBuild />
</workspace>
